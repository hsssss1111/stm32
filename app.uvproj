# Keil uVision project app.uvproj, settings and files
target ChipFlash (ARM-ADS)
  device: STM32F103ZC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: app
  c flags: Optim=1
  c define: STM32F10X_HD  _DEBUG_
  c include: .\uCOS-II\Ports;.\uCOS-II\Source;.\KN_CODE;..\app;.\STM32F103\lib
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ucos
    ./uCOS-II/Source/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group stm32
    ./uCOS-II/Ports/: os_cpu_c.c os_cpu_a.asm
    ./STM32F103/startup/: startup_stm32f10x.s
    ./STM32F103/: system_stm32f10x.c
    ./STM32F103/lib/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_wwdg.c stm32f10x_tim.c stm32f10x_fsmc.c
  group app
    ./KN_CODE/: main.c
    ./KN_CODE/app/: maintask.c
    ./KN_CODE/app/wifi/: wifi.c
  group driver
    ./KN_CODE/driver/uart/: uart.c
    ./KN_CODE/driver/dog/: dog.c
    ./KN_CODE/driver/led/: led.c
    ./KN_CODE/driver/lcd/: ili9320.c
  group lib
    ./KN_CODE/lib/: debug.c app_util.c
